RRECOMMENDS:packagegroup-wifi-tdx-cli:remove = "hostapd-example wireless-regdb-static"