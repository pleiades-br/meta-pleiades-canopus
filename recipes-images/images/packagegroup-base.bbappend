RDEPENDS:packagegroup-base-wifi:remove = "wpa-supplicant wireless-regdb-static"