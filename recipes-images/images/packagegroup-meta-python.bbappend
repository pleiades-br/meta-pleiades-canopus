RDEPENDS:packagegroup-meta-python3-ptest:remove = "python3-wpa-supplicant"